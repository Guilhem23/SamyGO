require tar.inc

SRC_URI[md5sum] = "4f9028d231c3e7d7bdd658e14e74c2d1"
SRC_URI[sha256sum] = "dc6c70d2071ca4a928460b6d68ab500a32e67d50255261a0d17765a307aeb350"

#SamyGO: keep this version, 1.22 has configure issues with native on os x
