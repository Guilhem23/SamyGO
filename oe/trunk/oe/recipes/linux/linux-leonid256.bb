
require linux-leonid_2.6.18.inc

KERNEL_DEFCONFIG = "defconfig_leonid256"
