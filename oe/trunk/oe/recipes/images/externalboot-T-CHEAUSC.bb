FIRMWARE_NAME = "T-CHEAUSC"

require externalboot-common.inc

COMPATIBLE_MACHINE = "leonid"

KERNEL_PACKAGE = "linux-leonid"
