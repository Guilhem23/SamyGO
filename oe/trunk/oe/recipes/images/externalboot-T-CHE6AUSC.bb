FIRMWARE_NAME = "T-CHE6AUSC"

require externalboot-common.inc

COMPATIBLE_MACHINE = "leonid"

KERNEL_PACKAGE = "linux-leonid256"
