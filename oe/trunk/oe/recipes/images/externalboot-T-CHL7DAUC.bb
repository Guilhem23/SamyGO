FIRMWARE_NAME = "T-CHL7DAUC"

require externalboot-common.inc

COMPATIBLE_MACHINE = "leonid"

KERNEL_PACKAGE = "linux-leonid"
