FIRMWARE_NAME = "T-CHE7AUSC"

require externalboot-common.inc

COMPATIBLE_MACHINE = "ssdtv"

KERNEL_PACKAGE = "linux-leonid"
