FIRMWARE_NAME = "T-CHL5DAUC"

require externalboot-common.inc

COMPATIBLE_MACHINE = "leonid"

KERNEL_PACKAGE = "linux-leonid256nopci"
