FIRMWARE_NAME = "T-CHL5DEUC"

require externalboot-common.inc

COMPATIBLE_MACHINE = "ssdtv"

KERNEL_PACKAGE = "linux-leonid256nopci"
