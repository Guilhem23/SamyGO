FIRMWARE_NAME = "T-SPHAUSC"

require externalboot-common.inc

COMPATIBLE_MACHINE = "polaris"

KERNEL_PACKAGE = "linux-polaris"
