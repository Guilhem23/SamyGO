FIRMWARE_NAME = "T-CHU7DEUC"

require externalboot-common.inc

COMPATIBLE_MACHINE = "leonid"

KERNEL_PACKAGE = "linux-leonid"
