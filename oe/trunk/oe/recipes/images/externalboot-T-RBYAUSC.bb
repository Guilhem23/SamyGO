FIRMWARE_NAME = "T-RBYAUSC"

require externalboot-common.inc

COMPATIBLE_MACHINE = "polaris"

KERNEL_PACKAGE = "linux-polaris"
