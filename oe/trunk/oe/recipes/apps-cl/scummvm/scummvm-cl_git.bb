require scummvm-cl.inc

SRCREV = "b929699ad20dc06a379f"
SRC_URI = "git://github.com/scummvm/scummvm.git;protocol=git;branch=master"

S = "${WORKDIR}/git"
