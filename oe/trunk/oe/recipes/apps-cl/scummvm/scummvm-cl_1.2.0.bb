require scummvm-cl.inc

S = "${WORKDIR}/scummvm-${PV}"

SRC_URI[md5sum] = "fae9a3dbd4d2892664a8bcb161eb8d9a"
SRC_URI[sha256sum] = "3ffc594d7ce3c14ad9bbbfaec70479f83a8bdbda81cf1eacf2988127f1d4dac0"
