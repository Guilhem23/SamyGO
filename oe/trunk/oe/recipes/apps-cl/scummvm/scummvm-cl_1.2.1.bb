require scummvm-cl.inc

S = "${WORKDIR}/scummvm-${PV}"

SRC_URI[md5sum] = "b1d224d7640bc7fdccaca958164b31df"
SRC_URI[sha256sum] = "488e0fc0fb48509f8d2dcc8f87a77d03655e8ae0e9f4333963aaa07ff75f2a09"
