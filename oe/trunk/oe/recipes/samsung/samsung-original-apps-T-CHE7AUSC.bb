FIRMWARE_NAME = "T-CHE7AUSC"
# 1013.0
SRC_URI = "http://downloadcenter.samsung.com/content/FM/200909/20090922135709687/2009_DTV_2G_firmware.exe;md5sum=1b3b9752418df97ffef29341f071e568"
FLASH_RFS_VERSION = "1_2G_64_512-4"

require firmiszip.inc
require samsung-original-apps-common.inc

