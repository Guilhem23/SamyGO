FIRMWARE_NAME = "T-CHU7DAUC"
# 1008.0
SRC_URI = "http://downloadcenter.samsung.com/content/FM/200908/20090806125546515/T-CHU7DAUC.exe;md5sum=7432b4087ae1ebb4e62ba9156e1d0ccf"
FLASH_RFS_VERSION = "1_2G_64_512-4"

require firmiszip.inc
require samsung-original-apps-common.inc

