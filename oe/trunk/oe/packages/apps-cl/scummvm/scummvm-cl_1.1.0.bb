require scummvm-cl.inc
