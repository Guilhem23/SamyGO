require scummvm-cl.inc

SRC_URI = "svn://scummvm.svn.sourceforge.net/svnroot/scummvm/scummvm;module=trunk;proto=http"

S = "${WORKDIR}/trunk"
