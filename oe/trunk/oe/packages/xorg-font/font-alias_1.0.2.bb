require xorg-font-common.inc

DESCRIPTION = "X font aliases."

DEPENDS = "util-macros"
RDEPENDS = "util-macros"

PE = "1"
PR = "${INC_PR}.0"
