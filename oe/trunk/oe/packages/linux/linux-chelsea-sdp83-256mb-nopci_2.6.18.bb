
require linux-chelsea-sdp83_2.6.18.bb

KERNEL_DEFCONFIG = "defconfig_sdp83-256mb-nopci"
