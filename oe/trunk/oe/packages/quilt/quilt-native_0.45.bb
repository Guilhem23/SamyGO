PV="0.45"
require quilt-native.inc
SRC_URI += "file://cygwin.patch;patch=1"
