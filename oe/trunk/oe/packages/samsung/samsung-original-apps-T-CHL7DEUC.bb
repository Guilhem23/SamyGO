FIRMWARE_NAME = "T-CHL7DEUC"

require samsung-original-apps-common.inc

#PACKAGES = "samsung-original-apps-chl7deuc"
