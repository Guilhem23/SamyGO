require firmware.inc
require firmisrar.inc
require firmware-package.bbclass
require firmware-do-stage.inc
require firmware-${FIRMWARE_NAME}.inc

PR = "r0"

