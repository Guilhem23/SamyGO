FIRMWARE_NAME = "T-CHE7AUSC"

require samsung-original-apps-common.inc
