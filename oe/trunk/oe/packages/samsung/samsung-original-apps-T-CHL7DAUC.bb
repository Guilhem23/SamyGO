FIRMWARE_NAME = "T-CHL7DAUC"

require samsung-original-apps-common.inc
require samsung-firmware-common.inc
