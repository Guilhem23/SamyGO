FIRMWARE_NAME = "T-CHU7DAUC"

require samsung-original-apps-common.inc
require samsung-firmware-common.inc
