FIRMWARE_NAME = "T-CHEAUSC"

require samsung-original-apps-common.inc
