FIRMWARE_NAME = "T-CHU7DEUC"

require samsung-original-apps-common.inc
