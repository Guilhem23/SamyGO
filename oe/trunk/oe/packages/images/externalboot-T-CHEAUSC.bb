FIRMWARE_NAME = "T-CHEAUSC"

require externalboot-common.inc

COMPATIBLE_MACHINE = "sdp83"
