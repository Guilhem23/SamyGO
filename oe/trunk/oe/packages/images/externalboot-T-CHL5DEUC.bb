FIRMWARE_NAME = "T-CHL5DEUC"

require externalboot-common.inc

