FIRMWARE_NAME = "T-CHL5DAUC"

require externalboot-common.inc

COMPATIBLE_MACHINE = "sdp83"

KERNEL_PACKAGE = "linux-chelsea-sdp83-256mb-nopci"
