FIRMWARE_NAME = "T-CHU7DEUC"

require externalboot-common.inc

