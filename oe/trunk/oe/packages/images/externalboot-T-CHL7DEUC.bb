FIRMWARE_NAME = "T-CHL7DEUC"

require externalboot-common.inc

COMPATIBLE_MACHINE = "sdp83"
