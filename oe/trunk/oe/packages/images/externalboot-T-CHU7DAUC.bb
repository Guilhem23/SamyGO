FIRMWARE_NAME = "T-CHU7DAUC"

required externalboot-common.inc

