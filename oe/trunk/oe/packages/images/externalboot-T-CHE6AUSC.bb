FIRMWARE_NAME = "T-CHE6AUSC"

required externalboot-common.bb

