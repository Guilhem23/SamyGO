FIRMWARE_NAME = "T-CHE7AUSC"

require externalboot-common.inc

COMPATIBLE_MACHINE = "sdp83"

KERNEL_PACKAGE = "linux-chelsea-sdp83"
