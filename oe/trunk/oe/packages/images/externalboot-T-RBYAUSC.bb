FIRMWARE_NAME = "T-RBYAUSC"

required externalboot-common.inc

COMPATIBLE_MACHINE = "sdp75"

