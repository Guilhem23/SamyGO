FIRMWARE_NAME = "T-SPHAUSC"

require externalboot-common.inc

COMPATIBLE_MACHINE = "sdp75"

KERNEL_PACKAGE = "linux-chelsea-sdp75"
