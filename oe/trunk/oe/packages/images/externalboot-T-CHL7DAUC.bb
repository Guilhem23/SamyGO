FIRMWARE_NAME = "T-CHL7DAUC"

require externalboot-common.inc

COMPATIBLE_MACHINE = "sdp83"
