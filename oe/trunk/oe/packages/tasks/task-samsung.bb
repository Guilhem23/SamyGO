PACKAGES = task-samsung
DESCRIPTION = "Meta-package Samsung SELP"
ALLOW_EMPTY = 1
PACKAGES = "${PN}"

PV = "0.0.1"
PR = "r0"

DEPENDS += "task-samsung-toolchain"
RDEPENDS = " "
