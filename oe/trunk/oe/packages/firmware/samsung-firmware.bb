require firmware.inc
require firmisrar.inc
require firmware-package.bbclass

PR = "r0"

SRC_URI = "http://downloadcenter.samsung.com/content/FM/200910/20091030222802906/T-CHL7DEUC.exe;md5sum=2cdfe576c619c9ebf6698b22e9965127"

FIRMWARE_NAME = "T-CHL7DEUC"

