
require externalboot-common.inc

