FIRMWARE_NAME = "T-CHE7AUSC"

require externalboot-common.inc

COMPATIBLE_MACHINE = "leonid"

KERNEL_PACKAGE = "linux-leonid"
