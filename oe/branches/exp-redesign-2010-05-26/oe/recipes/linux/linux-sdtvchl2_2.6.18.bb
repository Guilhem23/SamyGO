
require linux-sdtvchl2_2.6.18.inc

KERNEL_DEFCONFIG = "defconfig_sdtvchl2"
