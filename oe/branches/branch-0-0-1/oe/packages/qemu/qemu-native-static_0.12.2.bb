require qemu-native_${PV}.bb

EXTRA_OECONF += "--static"

